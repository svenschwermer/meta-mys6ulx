FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://no-werror.patch "
